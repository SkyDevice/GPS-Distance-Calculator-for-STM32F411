# Keil uVision project Project.uvprojx, settings and files
target Nucleo STM32F411RE (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo STM32F411RE
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\Main;.\Source;.\Include;.\Instruction
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Documentation
    ./Documentation/: ProjectInfo.txt
  group Main
    ./Main/: main.c
  group Source
    ./Source/: startup_stm32f411xe.s system_stm32f4xx.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_nvic.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_it.c
  group Instruction
    ./Instruction/: stm32f411_mcuDevice.c stm32f411_mcuRedirect.c stm32f411_dspDevice.c stm32f411_dspInterface.c stm32f411_stdFunctions.c stm32f411_gpsDevice.c stm32f411_gpsCoordinates.c
